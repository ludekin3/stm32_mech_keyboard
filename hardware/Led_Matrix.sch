File: hardware/Led_Matrix.sch (KiCad schematic (older format))
At the start: 65 parts

Commit message: Update Led_Matrix.sch
